# Keil uVision project MFC.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: MFC +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE;..\USER
  group USER
    ./: STARTUP.A51 STC12C5A60S2.h lcd1602.h main.c PID.c
  group HARDWARE
    ../HARDWARE/: key.c lcd1602.c pwm.c adc.c Uart1.c
